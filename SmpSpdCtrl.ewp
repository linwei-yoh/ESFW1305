# IAR project SmpSpdCtrl.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SpdCtrl.hex
  ILINK.IlinkOutputFile: SmpSpdCtrl.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../: ReadMe.txt
  group App
    Src/App/: main.c
  group Driver/ADC
    Src/ADC/: ADC.c
  group Driver/EEPROM
    Src/EEPROM/: Eeprom.c
  group Driver/Encrypt
    Src/Encrypt/: Encrypt.c
  group Driver/IO
    Src/IOCtrl/: IOCtrl.c
  group Driver/Menu
    Src/Menu/: MenuCtrl.c MenuData.c
  group Driver/Motor
    Src/App/: MotorCtrl.c MotorModeCtrl.c MotorParam.c
  group Driver/Panel
    Src/Panel/: PanelCtrl.c
  group Driver/Panel/Display
    Src/Display/: Display.c
  group Driver/Panel/KeyCtrl
    Src/KeyCtrl/: KeyCtrl.c
  group Driver/Panel/TM1618
    Src/TM1618/: TM1618.c
  group Driver/PwmGen
    Src/PwnGen/: PwmGen.c
  group Driver/SpdCalc
    Src/SpdCalc/: SpdCalc.c
  group Driver/Timer
    Src/Timer/: TIM4.c
